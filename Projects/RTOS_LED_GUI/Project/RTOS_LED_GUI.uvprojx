# Keil uVision project RTOS_LED_GUI.uvprojx, settings and files
target RTOS_LED_GUI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000)
  output: RTOS_LED_GUI +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,X_GUI_USE_FREERTOS
  c include: ..\App;..\BSP\led;..\BSP\key;..\BSP\lcd;..\BSP\usart;..\BSP\flash;..\Core;..\GUI;..\GUI\inc;..\GUI\arch\Inc;..\GUI\drv;..\GUI\OEM_Face;..\RTOS\include;..\RTOS\port;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: main.c GUI_LED_Dialog.c
  group BSP
    ../BSP/led/: bsp_led.c
    ../BSP/key/: bsp_key.c
    ../BSP/lcd/: bsp_lcd.c bsp_nt35510_lcd.c bsp_lcd_ext.c
    ../BSP/usart/: bsp_debug_usart.c
    ../BSP/flash/: bsp_spi_flash.c
    ../BSP/touch/: bsp_touch.c
  group Core
    ../Core/: stm32f4xx_it.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group FreeRTOS
    ../RTOS/src/: tasks.c queue.c list.c timers.c event_groups.c croutine.c
    ../RTOS/port/: port.c heap_4.c
  group emXGUI
    ../GUI/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../GUI/arch/: GUI_Arch.c GUI_GPU.c EXT_LCD_Arch.c GUI_TouchPanel.c GUI_TouchPanel_Calibration.c
    ../GUI/drv/: gui_lcd_port.c gui_touch_port.c gui_input_port.c gui_font_port.c gui_mem_port.c gui_log_port.c gui_fs_port.c gui_resource_port.c gui_picture_port.c
    ../App/: GUI_Startup.c
    ../GUI/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
    ../GUI/libs/: emXGUI100_MDK_M4.lib x_libc_MDK_M4.lib
  group STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_pwr.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_i2c.c stm32f4xx_sdio.c stm32f4xx_flash.c
