# Keil uVision project SmartLED.uvprojx, settings and files
target SmartLED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartLED +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,X_GUI_USE_FREERTOS,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\User\bsp;..\..\emXGUI_Lib\inc;..\..\emXGUI_Lib\drv;..\..\emXGUI_Lib\arch\Inc;..\..\emXGUI_Lib\app\base;..\..\emXGUI_Lib\arch;..\..\User\bsp\FATFS\option;..\..\User\bsp\FATFS;..\..\User\app\GUI_Demo;..\..\emXGUI_Lib\libs;..\..\User\OwnerDraw;..\..\User\app\Board_App;..\..\User\app\Board_App\LED_Key;..\..\User\bsp\cm_backtrace;..\..\emXGUI_Lib\app\base\boot_interface\pic_load
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Output\SmartLED.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
  group BSP
    ../../User/bsp/uart/: bsp_debug_usart.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/fsmc/: bsp_fsmc.c
    ../../User/bsp/flash/: bsp_spi_flash.c
    ../../User/bsp/sdio/: bsp_sdio_sd.c
    ../../User/bsp/lcd/: DMA_LCD.c bsp_nt35510_lcd.c
    ../../User/bsp/touch/: bsp_i2c_touch.c gt9xx.c
  group cm_backtrace
    ../../User/bsp/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../User/bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Fatfs
    ../../User/bsp/FATFS/: diskio.c ff.c
    ../../User/bsp/FATFS/option/: extern_cc936.c
  group FRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group emxgui/arch
    ../../emXGUI_Lib/arch/: GUI_GPU.c GUI_Arch.c EXT_LCD_Arch.c
    ../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
  group emxgui/res
    ../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_24_4BPP.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../emXGUI_Lib/drv/: gui_lcd_port.c gui_log_port.c gui_font_port.c gui_mem_port.c gui_startup.c gui_touch_port.c gui_input_port.c gui_resource_port.c gui_fs_port.c gui_picture_port.c
  group emxgui/inc
    ../../emXGUI_Lib/inc/: def.h emXGUI.h emXGUI_Arch.h GUI_Font_XFT.h x_libc.h x_obj.h
  group emxgui/libs
    ../../emXGUI_Lib/libs/: emXGUI100_MDK_M4.lib x_libc_MDK_M4.lib libpng_MDK_M4.lib libjpeg_MDK_M4.lib x_obj.cpp
  group base_app
    ../../emXGUI_Lib/app/base/: gui_desktop.c
    ../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c boot_logo.c
    ../../emXGUI_Lib/app/base/res_writer/: GUI_RES_Writer_Dialog.c backend_res_writer.c
  group gui_app
    ../../User/app/Board_App/: GUI_Board_App_Desktop.c
    ../../User/app/GUI_Demo/: CListMenu.cpp
  group OEM_Face
    ../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_TextBox.c OEM_ScrollBar.c
  group App
    ../../User/app/Board_App/LED_Key/: GUI_LED_KEY_Dialog.c
